# Keil uVision project tracker.uvprojx, settings and files
target stm32f030f4 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: tracker +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./: README.txt
    ./sources/: core.c debug.c gpio.c init.c main.c mux.c uart.c interrupt.c stepper_drv.c Buttons.c commands.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.2.3
